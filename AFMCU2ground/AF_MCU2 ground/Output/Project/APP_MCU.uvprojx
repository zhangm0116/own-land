# Keil uVision project APP_MCU.uvprojx, settings and files
target DEMO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_MCU +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT,__FPU_USED,STM32F40_41xxx
  c include: ..\..\Library\Libc;..\..\Library\Libc\sys;..\..\App;..\..\Bsp;..\..\CMSIS;..\..\Drive;..\..\Library\Finsh;..\..\Library\STM32F40x_StdPeriph_Driver\inc;..\..\Library\STM32F4x7_ETH_Driver\inc;..\..\RTOS\include;..\..\Lwip\src;..\..\Lwip\src\arch\include;..\..\Lwip\src\include;..\..\Lwip\src\include\ipv4;..\..\Lwip\src\include\netif;..\..\Lwip\web_server
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../App/: startup.c application.c common.c interface.c queue.c uart_protocol.c fpga_upgrade.c mcu_api.c spansion.c spi_flash.c upgrade.c ymodem.c
  group BSP
    ../../Bsp/: board.c stm32f4_eth.c stm32f4_i2c.c stm32f4_it.c stm32f4_spi.c stm32f4_uart.c
  group DRIVE
    ../../Drive/: i2c_bit_ops.c i2c_bus.c serial.c spi_bus.c
  group FINSH
    ../../Library/Finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RTOS
    ../../RTOS/kernel/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group CMSIS
    ../../CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c
  group PORT
    ../../RTOS/port/: context_rvds.S cpuport.c
  group LIBC
    ../../Library/Libc/: ctype.c qsort.c rand.c stdlib.c string.c time.c
  group STM32F40x_DEVICELIB
    ../../Library/STM32F40x_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Library/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Lwip
    ../../Lwip/web_server/: fs.c
    ../../Lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Lwip/src/arch/: sys_arch.c
    ../../Lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Lwip/src/netif/: etharp.c ethernetif.c
  group lwipapi
    ../../Lwip/web_server/: httpd.c httpd_cgi_ssi.c
    ../../App/: udp_connect.c
software components: CMSIS:CORE 4.1.0
